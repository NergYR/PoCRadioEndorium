options:
  parameters:
    author: PoCRadio
    description: Réception DSSS pour système radio airsoft
    generate_options: qt_gui
    id: airsoft_dsss_receiver
    output_language: python
    title: Airsoft DSSS Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Charge le signal DSSS
      depuis le fichier .bin
    file: gnuradio_dsss_noisy.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    comment: |-
      Séquence PN pour
      désétalement
    file: gnuradio_pn_sequence.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Désétalement:
      multiplie par PN
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: |-
      Extrait partie réelle
      (BPSK)
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: |-
      Intègre sur
      spreading_factor
    decim: spreading_factor
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Décision binaire
      (seuil à 0)
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Signal reçu
    label2: Signal désétalé
    name: '"Signal temporel"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: blue
    grid: 'True'
    label1: Après désétalement
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_1, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
